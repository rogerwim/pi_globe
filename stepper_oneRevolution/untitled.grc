options:
  parameters:
    generate_options: qt_gui
    id: default1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2084000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: 100e6
    gain: '73'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
